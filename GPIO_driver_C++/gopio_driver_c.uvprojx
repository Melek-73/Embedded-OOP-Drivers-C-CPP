# Keil uVision project gopio_driver_c.uvprojx, settings and files
target stm32f7 (6240000::V6.24::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: gopio_driver_c
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Personnel\Autoformation\GPIO_driver_C\stm32f7\libs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group app
    ./: main.cpp
  group drivers
    ./: gpio_stm32f7.h
  group libs
    ./: gpio_lib_stm32f7.h gpio_lib_stm32f7.cpp
software components: CMSIS:CORE 6.1.1, Device:Startup 1.2.5
