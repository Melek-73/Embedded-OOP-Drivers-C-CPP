# Keil uVision project led-class.uvprojx, settings and files
target stm32f7 (6240000::V6.24::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: led-class
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group app
    ./: Led.c Led.h main.c PowerLed.c PowerLed.h MedicalLed.c MedicalLed.h
  group drivers
    ./: uart.c uart.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.2.5
